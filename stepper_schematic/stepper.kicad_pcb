# Repository bibishte/firmwares

File README:

This is a stepper motor controller. Based on DRV8825 by Texas Instruments. The programme is made with Netbeans v7.2 
and the schematic with KiCAD v2.8.12. 

This is my first project. It has two elements. The first one is the schematic and the PCB under CC license and firmware under GPL v2. It is used for controlling stepper motor up to 2.5Amps
via serial interface RS232/RS485 for home or ingustrial automation or parallel galvanic opto isolated interface compatible with RepRap printers, Milling machines Mach3, LinuxCNC.

The PCB and schematic is under CC license.

## KiCad design stepper_schematic/stepper.kicad_pcb

File stepper_schematic/README:

This is a stepper motor controller. Based on DRV8825 by Texas Instruments.
The firmware is published by GPL2 https://github.com/bibishte/firmwares/tree/master/stepper_firmowares

  I have decided to make it becouse my dad bought a few kits from ebay and they didn't work as expected.
Also the good once were too expensive or too big or the shipment is too difficult and expensive for me or they have inappropriate property interface.
  During the design i had a lot of challenges like: what kind of driver and microcontroller should I use, what kind of parameter should have the driver, 
which kind of command protocol should be implemented. At the end with the guidance of my dad we decided that it should have easy serial interface RS232
or RS485. Also we decided that the microcontroller probably should be Atmega8 and the driver must approximately cover in between 2 to 3 Amps. Also the PCB
must have simple galvanic insolated interface with type direction/step to be able to work propperly into my future project for RepRap printer and CNC milling
machine. The best choice without any quality compromise is new brand of Texas Instrument chip DRV8825. This chip supports also microsteps mode up to 32
microsteps. During the development of schematic and PCB my dad has been guiding me with electronic rules and laws. 
  After a month the design part and interface was done. It turned out that this was the easyest and the fastest part of the project. After that started a horrible 
procedure for procurement of components and PCB manufecturer, clarifing the PCB manufactoring technology and so on. After mont and a half I had all the
components and PCBs, I thought that this was the end but this wasn't the end of the challenge. The DRV8825 driver I couldnt solder manually. My dad purchased the
solder paste and the stencil. After that everything started going in the right and espected way. The programme was created and uploaded after a few optimizations of
the size of code.
  If you rather to save all this pangs you could order me to make it for you, becouse I already have the needed materials and the tools. What can I offer the total 
PCB(gold-nickel plated) cost is $95. In this price wasn't included the box(http://store.comet.bg/Catalogue/Product/7844/) and the 
shipment. If you don\'t need all the features of the project just write me on bibishte@gmail.com and I will recalculate it.
  Everyone who has decided to make it by himself feel free to ask me on bibishte@gmail.com

Parts:
C1, C2: 12p
C3, C4, C6, C7: 10u
C5: 680n
C8, C9, C11, C12, C15: 220n
C10: 330u
C13, C17: 220u
C14: 10n
C16: 100n
D1: 1N5819GLX
D2: 1N4001
IC1: ATMEGA8-P; DIL28
IC2: SP485; DIP8
IC3, IC4, IC5, IC6, IC7: LTV-814; DIP4
IC8: LM2575_PENTAWATT_D2PAK
JP1, JP2, JP3, JP4, JP5: JUMPER
L1: 330u
P1: CONN_6
P2: HN1X6
P3: HD-515R 8P
P4: HD-515R 2P
P5: HD-515R 4P
P6, P7, P8, P9: 3mm
R1: 10k
R2: 120
R3, R4: 820
R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R16, R17: 4.7k
R15: 50k
R18: 1M
R19, R20: 0.2
RV1: 30k
U1: MAX232
U2, U3: 6N137
U4: DRV8825PWP
X1: QUARTZ

Connections:
+3.3V: C8.1, R15.2, U4.15 (V3P3OUT)
+5V: C10.1, C11.1, IC1.7 (VCC), IC1.20 (AVCC), IC2.8 (VCC), IC8.4, JP1.2, JP3.2, JP4.2, JP5.2, L1.1, P1.4, P2.6, R1.1, R4.2, R12.1, R13.1, R14.1, R16.1, R17.1, U1.16 (VCC), U2.7 (enable), U2.8 (Vcc), U3.7 (enable), U3.8 (Vcc)
+36V: C12.1, C13.1, C16.1, D2.1 (A), P4.1, R18.1, U4.4 (VMA), U4.11 (VMB)
/DECAY: IC1.24 ((ADC1)PC1), JP1.1, JP2.1, U4.19 (DECAY)
/DIR: IC1.16 ((~SS~/OC1B)PB2), U3.6 (Vout), U4.20 (DIR)
/ENBL: IC1.11 ((T1)PD5), IC4.4, R16.2, U4.21 (nENBL)
/FAULT: IC1.15 ((OC1A)PB1), IC7.1, R12.2, U4.18 (nFAUT)
/HOME: IC1.25 ((ADC2)PC2), IC6.1, R14.2, U4.27 (nHOME)
/M0: IC1.26 ((ADC3)PC3), JP5.1, U4.24 (MODE0)
/M1: IC1.27 ((ADC4/SDA)PC4), JP4.1, U4.25 (MODE1)
/M2: IC1.28 ((ADC5/SCL)PC5), JP3.1, U4.26 (MODE2)
/MISO: IC1.18 ((MISO)PB4), P2.2
/MOSI: IC1.17 ((MOSI/OC2)PB3), P2.1
/PB2: IC1.14 ((ICP)PB0), IC2.2 (~RE~), IC2.3 (DE)
/REF: RV1.2, U4.12 (AVREF), U4.13 (BVREF)
/RESET: C5.1, IC1.1 (PC6(~RESET~)), P2.4, R1.2
/RRX: IC2.6 (A), P1.3, R2.1, R4.1, U1.8 (R2IN)
/RST: IC3.4, R17.2, U4.16 (nRESET)
/RTX: IC2.7 (B), P1.2, R2.2, R3.2, U1.14 (T1OUT)
/RXD: IC1.2 ((RXD)PD0), IC2.1 (RO), U1.9 (R2OUT)
/SCL: IC1.19 ((SCK)PB5), P2.3
/SLEEP: IC5.4, R13.2, U4.17 (nSLEEP)
/STEP: IC1.23 ((ADC0)PC0), U2.6 (Vout), U4.22 (STEP)
/TXD: IC1.3 ((TXD)PD1), IC2.4 (DI), U1.11 (T1IN)
/X+: P1.6, R10.1, R11.1
GND: C1.2, C2.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C15.2, C17.2, D1.1 (A), IC1.8 (GND), IC1.22 (AGND), IC2.5 (GND), IC3.3, IC4.3, IC5.3, IC6.2, IC7.2, IC8.3, IC8.5, JP2.2, P1.5, P2.5, P4.2 (PM), R3.1, R19.2, R20.2, RV1.3, U1.15 (GND), U2.5 (GND), U3.5 (GND), U4.14 (GND), U4.28 (GND), U4.29 (pad)
GNDPWR: IC3.2, IC4.2, IC5.2, IC6.3, IC7.3, P3.5, U2.3 (Cathode), U3.3 (Cathode)
unnamed: C6.1, U1.2 (V+)
unnamed: C3.2, U1.3 (C1-)
unnamed: C3.1, U1.1 (C1+)
unnamed: C4.2, U1.5 (C2-)
unnamed: C4.1, U1.4 (C2+)
unnamed: IC7.4, P3.3, R11.2
unnamed: P3.6, R8.1
unnamed: P3.2, R9.1
unnamed: C7.1, U1.6 (V-)
unnamed: P3.1, R7.1
unnamed: P3.7, R5.1
unnamed: C2.2, IC1.10 (PB7(XTAL2/TOSC2)), X1.2
unnamed: C1.1, IC1.9 (PB6(XTAL1/TOSC1)), X1.1
unnamed: P5.1, U4.5 (AOUT1)
unnamed: C14.1, U4.1 (CP1)
unnamed: P5.4, U4.10 (BOUT1)
unnamed: P5.3, U4.8 (BOUT2)
unnamed: P5.2, U4.7 (Aout2)
unnamed: C14.2, U4.2 (CP2)
unnamed: R20.1, U4.6 (ISENA)
unnamed: R19.1, U4.9 (ISENB)
unnamed: C16.2, R18.2, U4.3 (VCP)
unnamed: P3.4, R6.1
unnamed: D1.2 (K), IC8.2, L1.2
unnamed: IC6.4, P3.8, R10.2
unnamed: R6.2, U3.2 (Anode)
unnamed: R5.2, U2.2 (Anode)
unnamed: C9.1, R15.1, RV1.1
unnamed: IC3.1, R7.2
unnamed: IC4.1, R8.2
unnamed: IC5.1, R9.2
unnamed: C15.1, C17.1, D2.2 (K), IC8.1

Board: 2 copper layers, 68 parts (16 on the bottom side), 59 nets.

## Code that names these connections

File stepper_firmowares/config.h:

/************************************************************************
 Title:    Macros and configuration of ports for DRV8825
 Author:   Bilyana Borisova <bibishte@gmail.com>
 File:     $Id: config.h 2015/04/19
 Software: AVR-GCC 4.9.2, AVR Libc 1.8.0
 Hardware: DRV8825 & ATmega8
 License:  GNU General Public License v2
 Usage:    see Doxygen manual

 LICENSE:
 Copyright (C) 2015 Bilyana Borisova

 This program is free software; you can redistribute it and/or modify
 it under the terms of the GNU General Public License v2 as published by
 the Free Software Foundation; either version 2 of the License, or
 any later version.

 This program is distributed in the hope that it will be useful,
 but WITHOUT ANY WARRANTY; without even the implied warranty of
 MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 GNU General Public License v2 for more details.

 ************************************************************************/

#ifndef CONFIG_H_
#define CONFIG_H_
/** 
 *  @defgroup biba_config config Library
 *  @code #include <config.h> @endcode
 * 
 *  @brief General macros for port manipolation and  port naming
 *
 *  Defines simple macros for setting bits and bytes for manipolating DRV8825
 * 
 *  @author Bilyana Borisova bibishte@gmail.com
 */

/**@{*/

#include <avr/io.h>

#define set_bit(byte, bit) byte |= (1 << bit)
#define clr_bit(byte, bit) byte &= ~(1 << bit)

/** \def set_as_output
 * Write logical one bit \c DDxn in IO register \c DDRx.
 * This will configure Pxn as an output pin. */
#define set_as_output(DDRx, DDxn) DDRx |= (1 << DDxn)

/** \def set_as_input
 * Write logical zero bit \c DDxn in IO register \c DDRx.
 * This will configure Pxn as an input pin. */
#define set_as_input(DDRx, DDxn) DDRx &= ~(1 << DDxn)

/** \def set_port
 * Write logic one bit \c PORTxn in IO register \c PORTx.
 * When the pin is configured as an output pin,
 * the port pin is driven high (one).*/
#define set_port(PORTx, PORTxn) PORTx |= (1 << PORTxn)

/** \def clr_port
 * Write logic zero bit \c PORTxn in IO register \c PORTx.
 * When the pin is configured as an output pin,
 * the port pin is driven low (zero).*/
#define clr_port(PORTx, PORTxn) PORTx &= ~(1 << PORTxn)

/** \def check_pin
 * Test whether bit \c PINxn in IO register \c PINx is set.
 * This will return a 0 if the port pin is driven low, and non-zero
 * if the pin is driven high. */
#define check_pin(PINx, PINxn) (PINx & (1 << PINxn))

#define CHECKPIN(x,y)	((x&(1<<y))!=0?1:0)

//Inputs
#define RXD                     PD0
#define HOME                    PC2
#define SCL                     PB5
#define MISO                    PB4
#define FAULT                   PB1

//Outputs

#define ENABLE_STEPPER          PD5
#define TXD                     PD1
#define MODE0                   PC3
#define MODE1                   PC4
#define MODE2                   PC5
#define DECAY                   PC1
#define STEP                    PC0
#define MOSI                    PB3
#define DIRECTION               PB2
#define DIR_485                 PB0

//Input ports
#define PRXD                     PORTD
#define PHOME                    PORTC
#define PSCL                     PORTB
#define PMISO                    PORTB
#define PFAULT                   PORTB

//Output ports

#define PENABLE_STEPPER          PORTD
#define PTXD                     PORTD
#define PMODE0                   PORTC
#define PMODE1                   PORTC
#define PMODE2                   PORTC
#define PDECAY                   PORTC
#define PSTEP                    PORTC
#define PMOSI                    PORTB
#define PDIRECTION               PORTB
#define PDIR_485                 PORTB

//Input direction
#define DRXD                     DDRD
#define DHOME                    DDRC
#define DSCL                     DDRB
#define DMISO                    DDRB
#define DFAULT                   DDRB

//Output direction

#define DENABLE_STEPPER          DDRD
#define DTXD                     DDRD
#define DMODE0                   DDRC
#define DMODE1                   DDRC
#define DMODE2                   DDRC
#define DDECAY                   DDRC
#define DSTEP                    DDRC
#define DMOSI                    DDRB
#define DDIRECTION               DDRB
#define DDIR_485                 DDRB

//Input pins
#define IRXD                     PIND
#define IHOME                    PINC
#define ISCL                     PINB
#define IMISO                    PINB
#define IFAULT                   PINB

//Output pins
#define IENABLE_STEPPER          PIND
#define ITXD                     PIND
#define IMODE0                   PINC
#define IMODE1                   PINC
#define IMODE2                   PINC
#define IDECAY                   PINC
#define ISTEP                    PINC
#define IMOSI                    PINB
#define IDIRECTION               PINB
#define IDIR_485                 PINB

#define true 1==1
#define false 1!=1

#endif /* CONFIG_H_ */

## Commit log

2015-04-19 Adding new files
2015-04-19 I have fixed the error in v0.1 in PCB and schematic and README file
2015-04-19 I forgot the changes and generate the pdf for documentation and schematics
2015-04-22 Optimization of messages due to saving space
